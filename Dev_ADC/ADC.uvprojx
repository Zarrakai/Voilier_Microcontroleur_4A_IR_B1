# Keil uVision project ADC.uvprojx, settings and files
target Simulé (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Afac_simulé
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;..\Services\USART;..\Drivers\Include;..\Services\GPIO;..\Services\TIMER;..\Services\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MesDrivers
    ../../../MesProjetsSTM32/MesDrivers/Source/: Driver_GPIO.c
    ../Drivers/Source/: MyUSART.c MyTimer.c MyADC.c
  group MesSources
    ../Services/USART/: comm_USART.c comm_USART.h
    ../Services/TIMER/: comm_TIMER.c comm_TIMER.h
    ../Services/GPIO/: comm_GPIO.c comm_GPIO.h
    ../Services/ADC/: comm_ADC.c comm_ADC.h
    ./Source/: princip.c
target Réel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: Afac_simulé
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Drivers\Include;..\Services\USART;..\Services\TIMER;..\Services\GPIO;..\Services\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
